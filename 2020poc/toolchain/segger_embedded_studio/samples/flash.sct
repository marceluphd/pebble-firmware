LR1 0x00000000 0x00100000  
{
  LR1_er1 0x00000000 0x00100000  
  {
    *.o (RESET, +First)
    *(InRoot$Sections)
    .ANY (+RO)
  }
  LR1_er2 0x20000000 0x00020000  
  {
    .ANY (+RW +ZI)
  }
}
